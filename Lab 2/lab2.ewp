# IAR project lab2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S8962 TexasInstruments LM3S8962
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: C:\StellarisWare; C:\StellarisWare\boards\ek-lm3s8962
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: lab2.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: compute.c main.c measure.c oledDisplay.c schedule.h startup_ewarm.c status.c warningAlarm.c
    ../../../../../../StellarisWare/driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
    ../../../../../../StellarisWare/boards/ek-lm3s8962/drivers/: rit128x96x4.c
