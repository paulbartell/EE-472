# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S6965 TexasInstruments LM3S6965
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: PART_LM3S2110; UART_BUFFERED; IAR_ARMCM3_LM; PACK_STRUCT_END=
  ICCARM.CCDiagSuppress: pa082, pe513, pe167, pe550, pe144, pe191, pe177, pa039, pa050
  ICCARM.CCIncludePath2: ; FreeRTOS\Common\ethernet; ..\..\..\..\; FreeRTOS\Common\drivers\LuminaryMicro; FreeRTOS\Common\include; FreeRTOS\Source\include; webserver; FreeRTOS\Common\ethernet\uIP\uip-1.0\uip; c:\StellarisWare\; C:\StellarisWare\boards\ek-lm3s8962
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ; c:\StellarisWare\
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: LM3Sxxxx.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c
  group AMedicalMonitor files
    ../Final Lab/: circularbuffer.c circularbuffer.h communication.c compute.c ekgCapture.c globals.h interrupts.c keypad.c measure.c oledDisplay.c schedule.c schedule.h startup.c startup.h startup_ewarm.c status.c tasks.h warningAlarm.c
  group Demo example files
    FreeRTOS/Common/Minimal/: IntQueue.c
    ./: IntQueueTimer.c timertest.c
    ParTest/: ParTest.c
  group Library files
    ../../../../../../StellarisWare/driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
    ./: rit128x96x4.c
    ../../../../../../StellarisWare/utils/: uartstdio.c
  group Scheduler files
    FreeRTOS/Source/portable/MemMang/: heap_2.c
    FreeRTOS/Source/: list.c queue.c tasks.c
    FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
